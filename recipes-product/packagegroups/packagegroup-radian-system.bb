SUMMARY = "Radian System Packages"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = "\
    v4l-utils \
"

