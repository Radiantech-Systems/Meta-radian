# The relay publishes MPEG-TS over SRT when remote streaming is enabled.
PACKAGECONFIG:append = " srt"
